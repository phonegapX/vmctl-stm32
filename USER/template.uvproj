# Keil uVision project template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\DELAY;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\CRC;..\HARDWARE\USART;..\HARDWARE\IWDG
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_crc.c stm32f10x_iwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group DELAY
    ../DELAY/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/CRC/: crc.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/IWDG/: iwdg.c
